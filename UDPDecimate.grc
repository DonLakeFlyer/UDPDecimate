options:
  parameters:
    generate_options: no_gui
    id: UDPDecimate
    output_language: python
    run_options: run
  states: {}

blocks:
- name: decimate_1
  id: variable
  parameters:
    value: '15'
  states: {}
- name: decimate_2
  id: variable
  parameters:
    value: '10'
  states: {}
- name: decimate_3
  id: variable
  parameters:
    value: '5'
  states: {}
- name: samp_rate2
  id: variable
  parameters:
    value: samp_rate/decimate_1
  states: {}
- name: samp_rate3
  id: variable
  parameters:
    value: samp_rate2/decimate_2
  states: {}
- name: samp_rate4
  id: variable
  parameters:
    value: samp_rate3/decimate_3
  states: {}
- name: taps1
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 1.5e3
    gain: '1.0'
    samp_rate: samp_rate
    width: 128e3 - 1.5e3
    win: firdes.WIN_BLACKMAN
  states: {}
- name: taps1_len
  id: variable
  parameters:
    value: len(taps1)
  states: {}
- name: taps2
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 1.5e3
    gain: '1.0'
    samp_rate: samp_rate2
    width: 16e3 - 1.5e3
    win: firdes.WIN_BLACKMAN
  states: {}
- name: taps2_len
  id: variable
  parameters:
    value: len(taps2)
  states: {}
- name: taps3
  id: variable_low_pass_filter_taps
  parameters:
    beta: 6.76 / 2
    cutoff_freq: 1.5e3
    gain: '1.0'
    samp_rate: samp_rate3
    width: 0.3e3
    win: firdes.WIN_KAISER
  states: {}
- name: taps3_len
  id: variable
  parameters:
    value: len(taps3)
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/parallels/repos/VHFCollarCompanion/far.dat
    repeat: 'False'
    type: float
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {state: disabled}
- name: blocks_udp_sink_0
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '20000'
    psize: '1472'
    type: complex
    vlen: '1'
  states: {}
- name: blocks_udp_sink_0_0
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '20001'
    psize: '1472'
    type: complex
    vlen: '1'
  states: {}
- name: final_decimation
  id: parameter
  parameters:
    label: Final decimation
    type: intx
    value: '4'
  states: {}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: decimate_2
    taps: taps2
    type: ccf
  states: {}
- name: fir_filter_xxx_0_0_0
  id: fir_filter_xxx
  parameters:
    decim: decimate_3
    taps: taps3
    type: ccf
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: decimate_1
    samp_rate: samp_rate
    taps: taps1
    type: ccc
  states: {}
- name: gain
  id: parameter
  parameters:
    label: Gain
    type: intx
    value: '21'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import cmath
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: airspy=0,sensitivity
    bb_gain0: '20'
    clock_source0: gpsdo
    freq0: pulse_freq
    gain0: gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: pulse_duration
  id: parameter
  parameters:
    label: Pulse duration (secs)
    type: eng_float
    value: '0.015'
  states: {}
- name: pulse_freq
  id: parameter
  parameters:
    label: Pulse Freq
    type: intx
    value: '146000000'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    type: eng_float
    value: 3e6
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [fir_filter_xxx_0_0, '0', fir_filter_xxx_0_0_0, '0']
- [fir_filter_xxx_0_0_0, '0', blocks_udp_sink_0, '0']
- [fir_filter_xxx_0_0_0, '0', blocks_udp_sink_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', fir_filter_xxx_0_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
